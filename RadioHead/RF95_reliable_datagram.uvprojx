# Keil uVision project RF95_reliable_datagram.uvprojx, settings and files
target RF95_SERVER (5060020::V5.06 (build 20)::ARMCC)
  device: STM32L151CB STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.0.2
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: RF95_SERVER
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER MCU_STM32L1XX
  c include: .\libs\RadioHead.1.46;.\libs\RadioHead.1.46\STM32ArduinoCompat\STM32L1XX;.\libs\STM32L1xx_StdPeriph_Driver\inc;.\libs\STM32_USB-FS-Device_Driver\inc;.\libs\CMSIS\Include;.\libs\CMSIS\Device\ST\STM32L1xx\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group src
    ./libs/RadioHead.1.46/examples/rf95/rf95_reliable_datagram_server/: RF95_reliable_datagram_server.cpp
    ./libs/RadioHead.1.46/examples/rf95/rf95_reliable_datagram_client/: RF95_reliable_datagram_client.cpp
  group STM32L1xx_StdPeriph_Driver
    ./libs/STM32L1xx_StdPeriph_Driver/src/: misc.c stm32l1xx_comp.c stm32l1xx_crc.c stm32l1xx_dbgmcu.c stm32l1xx_dma.c stm32l1xx_exti.c stm32l1xx_flash.c stm32l1xx_flash_ramfunc.c stm32l1xx_gpio.c stm32l1xx_iwdg.c stm32l1xx_pwr.c stm32l1xx_rcc.c stm32l1xx_rtc.c stm32l1xx_spi.c stm32l1xx_syscfg.c stm32l1xx_tim.c stm32l1xx_usart.c
  group Radiohead
    ./libs/RadioHead.1.46/: RH_RF95.cpp RHDatagram.cpp RHReliableDatagram.cpp RHGenericDriver.cpp RHSPIDriver.cpp RHHardwareSPI.cpp RHGenericSPI.cpp
  group Radiohead/STM32L1xx
    ./libs/RadioHead.1.46/STM32ArduinoCompat/STM32L1XX/: HardwareSPI.cpp HardwareSerial.cpp wirish.cpp USBSerial.cpp Print.cpp usb_prop.c usb_desc.c usb_endp.c usb_istr.c usb_pwr.c systick.c
  group STM32_USB-FS-Device_Driver
    ./libs/STM32_USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
target RF95_CLIENT (5060020::V5.06 (build 20)::ARMCC)
  device: STM32L151CB STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.0.2
  cpu: as above
  output: RF95_CLIENT
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER MCU_STM32L1XX
  c include: .\libs\STM32L1xx_StdPeriph_Driver\inc;.\libs\RadioHead.1.46;.\libs\RadioHead.1.46\STM32ArduinoCompat\STM32L1XX;.\libs\STM32_USB-FS-Device_Driver\inc;.\libs\CMSIS\Include;.\libs\CMSIS\Device\ST\STM32L1xx\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
software components: CMSIS:CORE 4.1.0, Device:Startup 1.0.0
