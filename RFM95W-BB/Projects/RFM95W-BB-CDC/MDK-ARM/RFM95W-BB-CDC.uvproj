# Keil uVision project RFM95W-BB-CDC.uvproj, settings and files
target RFM95W-BB-CDC (5060020::V5.06 (build 20)::ARMCC)
  device: STM32L151CB STMicroelectronics
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: RFM95W-BB-CDC
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER STM32L1XX_MD USE_RFM95W_BB
  c include: ..\inc;..\..\..\Libraries\CMSIS\Device\ST\STM32L1xx\Include;..\..\..\Libraries\STM32_USB-FS-Device_Driver\inc;..\..\..\Libraries\STM32L1xx_StdPeriph_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group src
    ../src/: main.c rfm95w_bb.c hw_config.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c stm32_it.c
    ../../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c
  group CMSIS
    ../src/: system_stm32l1xx.c startup_stm32l1xx_md.s
  group USB-FS-Device_Driver
    ../../../Libraries/STM32_USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group STM32L1xx_StdPeriph_Driver
    ../../../Libraries/STM32L1xx_StdPeriph_Driver/src/: stm32l1xx_usart.c stm32l1xx_exti.c stm32l1xx_flash.c stm32l1xx_gpio.c stm32l1xx_i2c.c stm32l1xx_rcc.c stm32l1xx_spi.c stm32l1xx_syscfg.c stm32l1xx_dma.c stm32l1xx_sdio.c stm32l1xx_pwr.c stm32l1xx_dbgmcu.c
